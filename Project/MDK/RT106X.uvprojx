# Keil uVision project RT106X.uvprojx, settings and files
target nor_sdram_zf_dtcm_v6 (6140000::V6.14::ARMCLANG)
  device: MIMXRT1064DVL6A NXP
  pack: NXP.MIMXRT1064_DFP.12.1.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x00000000,0x020000) IROM(0x70000000,0x400000) XRAM(0x20200000,0x0c0000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: RT106X
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: CPU_MIMXRT1064DVL6A,SKIP_SYSCLK_INIT,XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_DCD_ENABLE =1, XIP_BOOT_HEADER_ENABLE =1,PRINTF_FLOAT_ENABLE=1, SCANF_FLOAT_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, SCANF_ADVANCED_ENABLE=1, FSL_DRIVER_TRANSFER_DOUBLE_WEAK_IRQ=0,USB_STACK_BM, SERIAL_PORT_TYPE_UART, SDK_DEBUGCONSOLE=0,  __FPU_PRESENT=1 __TARGET_FPU_VFP __ARM_FP=0xe
  c misc: -fno-common  -fdata-sections  -fno-builtin  -mthumb -Wno-invalid-source-encoding
  c include: ..\CODE;..\..\Libraries\seekfree_libraries;..\..\Libraries\nxp_libraries\CMSIS\Include;..\..\Libraries\nxp_libraries\cmsis_drivers;..\..\Libraries\nxp_libraries\drives;..\..\Libraries\nxp_libraries\startup;..\..\Libraries\nxp_libraries\startup\MDK-ARM;..\..\Libraries\nxp_libraries\utilities;..\..\Libraries\nxp_libraries\utilities\debug_console;..\..\Libraries\nxp_libraries\utilities\str;..\..\Libraries\nxp_libraries\xip;..\..\Libraries\nxp_libraries\deceive;..\..\Libraries\nxp_libraries\components\serial_manager;..\..\Libraries\nxp_libraries\components\uart;..\..\Libraries\nxp_libraries\components\lists;..\..\Libraries\nxp_libraries\components\osa;..\..\Libraries\nxp_libraries\components\serial_manager\usb_cdc_adapter;..\..\Libraries\nxp_libraries\middleware\usb\include;..\..\Libraries\nxp_libraries\middleware\usb\phy;..\..\Libraries\nxp_libraries\middleware\usb\device;..\..\Libraries\nxp_libraries\middleware\sdmmc\inc;..\..\Libraries\nxp_libraries\middleware\sdmmc\port;..\..\Libraries\nxp_libraries\middleware\sdmmc\port\usdhc;..\..\Libraries\nxp_libraries\middleware\sdmmc\port\usdhc\interrupt;..\..\Libraries\nxp_libraries\middleware\sdmmc\src;..\..\Libraries\nxp_libraries\middleware\fatfs\source;..\..\Libraries\nxp_libraries\middleware\fatfs\source\fsl_sd_disk;..\..\Libraries\seekfree_libraries\common;..\..\Libraries\seekfree_peripheral;..\CODE\control;..\CODE;..\CODE\car;..\CODE\utility;..\CODE\bsp;.\board;..\..\Libraries\SimpleGUI\inc;..\CODE\gui;..\..\Libraries\StateMachineCompact;..\..\Libraries\nncu;..\..\Libraries\nncu\aiann;..\..\Libraries\nncu\cmsis_nn\Include;..\CODE\ai;.\RTE\_nor_sdram_zf_dtcm_v6
  asm define: __STARTUP_INITIALIZE_NONCACHEDATA
  memory RVCT4: ROM 0x70000000 size 0x400000
  memory RVCT6: RAM 0x20200000 size 0xc0000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\scf\MIMXRT1064xxxxx_flexspi_nor.scf
  group board
    ./board/: peripherals.c board.c clock_config.c pin_mux.c
  group components
    ../../Libraries/nxp_libraries/components/lists/: generic_list.c generic_list.h
    ../../Libraries/nxp_libraries/components/serial_manager/: serial_manager.c serial_manager.h serial_port_uart.c serial_port_uart.h
    ../../Libraries/nxp_libraries/components/uart/: lpuart_adapter.c
  group deceive
    ../../Libraries/nxp_libraries/deceive/: system_MIMXRT1064.h system_MIMXRT1064.c MIMXRT1064_features.h MIMXRT1064.h fsl_device_registers.h
  group drives
    ../../Libraries/nxp_libraries/drives/: fsl_adc.c fsl_adc.h fsl_cache.c fsl_cache.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_dmamux.c fsl_dmamux.h fsl_edma.c fsl_edma.h fsl_flexram.c fsl_flexram.h fsl_flexspi.c fsl_flexspi.h fsl_gpio.c fsl_gpio.h fsl_gpt.c fsl_gpt.h fsl_iomuxc.h fsl_lpspi.c fsl_lpspi.h fsl_lpuart.c fsl_lpuart.h fsl_lpuart_edma.c fsl_lpuart_edma.h fsl_pit.c fsl_pit.h fsl_pwm.c fsl_pwm.h fsl_qtmr.c fsl_qtmr.h fsl_src.c fsl_src.h fsl_tempmon.c fsl_tempmon.h
  group seekfree_libraries
    ../../Libraries/seekfree_libraries/: zf_flash.c zf_flash.h zf_gpio.c zf_gpio.h zf_iomuxc.c zf_iomuxc.h zf_pit.h zf_pwm.c zf_pwm.h zf_rom_api.c zf_rom_api.h zf_spi.c zf_spi.h zf_systick.c zf_systick.h zf_pit.c
    ../../Libraries/seekfree_libraries/common/: common.c common.h
  group seekfree_peripheral
    ../../Libraries/seekfree_peripheral/: SEEKFREE_FUN.c SEEKFREE_FUN.h SEEKFREE_IIC.c SEEKFREE_IIC.h SEEKFREE_VIRSCO.c SEEKFREE_VIRSCO.h
    ../CODE/gui/: SEEKFREE_OLED.c
  group startup
    ../../Libraries/nxp_libraries/startup/MDK-ARM/: startup_MIMXRT1064.s
  group user_c
    ../CODE/: main.cpp
    ../CODE/car/: car.cpp communication.cpp machine.cpp
    ../CODE/control/: pid.cpp magnet.cpp steer.cpp motor.cpp rit.cpp hall.cpp
    ../CODE/bsp/: encoder.cpp key.cpp led.cpp MCP4452.c bat.cpp storage.cpp
    ../CODE/utility/: scheduler.cpp retarget.c timer.cpp usage.cpp package.cpp filter.cpp
    ../CODE/gui/: screen.c gui.cpp layout.cpp gb2312.c
    ../CODE/ai/: deep.cpp model1.nncu.c model2.nncu.c model3.nncu.c
  group user_h
    ../CODE/car/: car.hpp car_config.h
    ../CODE/control/: pid.hpp magnet.hpp steer.hpp motor.hpp
    ../CODE/bsp/: encoder.hpp key.hpp led.hpp MCP4452.h route.h RT106X_config.h bat.hpp
    ../CODE/utility/: scheduler.hpp util.h timer.hpp filter.hpp
    ../../Libraries/seekfree_libraries/: headfile.h
    ../CODE/gui/: tree.hpp layout.hpp gui.hpp
  group utilities
    ../../Libraries/nxp_libraries/utilities/: fsl_assert.c
    ../../Libraries/nxp_libraries/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../Libraries/nxp_libraries/utilities/str/: fsl_str.c fsl_str.h
  group xip
    ../../Libraries/nxp_libraries/xip/: evkmimxrt1064_flexspi_nor_config.c evkmimxrt1064_sdram_ini_dcd.c fsl_flexspi_nor_boot.c
  group sgui
    ../../Libraries/SimpleGUI/src/: SGUI_Basic.c SGUI_Common.c SGUI_FontResource.c SGUI_IconResource.c SGUI_Interface.c SGUI_ItemsBase.c SGUI_List.c SGUI_Menu.c SGUI_Notice.c SGUI_ProcessBar.c SGUI_RealtimeGraph.c SGUI_ScrollBar.c SGUI_Text.c
  group dsp
    ../../Libraries/dspSource/ControllerFunctions/: arm_pid_init_f32.c arm_pid_reset_f32.c
    ../../Libraries/dspSource/StatisticsFunctions/: arm_mean_f32.c
    ../../Libraries/dspSource/FilteringFunctions/: arm_fir_f32.c arm_fir_fast_q15.c arm_fir_init_f32.c arm_fir_init_q15.c arm_fir_q15.c
    ../../Libraries/dspSource/FastMathFunctions/: arm_sqrt_q15.c
  group state machine
    ../../Libraries/StateMachineCompact/: StateMachine.cpp StateMachine.hpp
  group ai
    ../../Libraries/nncu/: nncie_port_nxpsdk.c nncie_imxrt10x0.lib
    ../../Libraries/nncu/cmsis_nn/Source/: arm_avepool_q7_HWC_nonsquare.c arm_convolve_1x1_HWC_q7_fast_nonsquare.c arm_convolve_HWC_q7_basic.c arm_convolve_HWC_q7_basic_nonsquare.c arm_convolve_HWC_q7_fast.c arm_convolve_HWC_q7_fast_nonsquare.c arm_convolve_HWC_q7_RGB.c arm_convolve_HWC_q15_basic.c arm_convolve_HWC_q15_fast.c arm_convolve_HWC_q15_fast_nonsquare.c arm_depthwise_separable_conv_HWC_q7.c arm_depthwise_separable_conv_HWC_q7_nonsquare.c arm_fully_connected_mat_q7_vec_q15.c arm_fully_connected_mat_q7_vec_q15_opt.c arm_fully_connected_q7.c arm_fully_connected_q7_opt.c arm_fully_connected_q15.c arm_fully_connected_q15_opt.c arm_nn_activations_q7.c arm_nn_activations_q15.c arm_nn_mat_mult_kernel_q7_q15.c arm_nn_mat_mult_kernel_q7_q15_reordered.c arm_nn_mult_q7.c arm_nn_mult_q15.c arm_nntables.c arm_pool_q7_HWC.c arm_q7_to_q15_no_shift.c arm_q7_to_q15_reordered_no_shift.c arm_relu_q7.c arm_relu_q15.c arm_softmax_q7.c arm_softmax_q15.c
